# Keil uVision project TennisTimer_nRF51.uvprojx, settings and files
target IDLFramework_nRF51 (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: IDLFramework_nRF51 +hex
  c flags: Optim=1 OneElfS=1
  c define: NRF51
  c misc: --cpp11
  c include: ..\Library\IDLFramework\inc;..\Library\nRF51\CMSIS;..\Library\nRF51\Hardware\inc;..\Library\nRF51\Radio\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group App
    ./: Application.cpp Application.h arm_startup_nrf51.s DefaultSettings.h hardwaredef.h main.cpp
  group IDLFramework
    ../Library/: IDLFramework_nRF51.lib
